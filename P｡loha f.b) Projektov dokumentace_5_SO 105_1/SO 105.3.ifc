Properties of the parts of a building model (IFC4X3_ADD2)

# File
Description: ViewDefinition [Ifc4X3NotAssigned]
File name: D:\_Projekty\2017_07 - SÚS Obchvat Dašic\4_PDPS\BIM\IFC\SO 105.3.ifc
Time: 2025-05-21T11:19:05
Author: Michal Švarc
Organization: DESKTOP-47J51D1
Written by: GeometryGymIFCcore v24.8.23.0 by Geometry Gym Pty Ltd built 2024-08-23T03:53:20
Made in: Civil 3D 2024 IfcInfra Plugin v13.6.170.0
Comment: name
Comment: time_stamp
Comment: author
Comment: organization
Comment: preprocessor_version
Comment: originating_system
Comment: authorization

# IfcProject, SO 105
Summary - Title: CAD Studio Silniční šablona; Author: Martin Folber, Ondřej Vojtěchovský, Jakub Kareš; HyperlinkBase: www.cadstudio.cz
Custom_Properties - Investor: Správa a údržba silnic Pardubického kraje, Doubravice 98, 533 53 Pardubice; Zakázka: přeložka silnice II/322 Černá za Bory - Dašice; Stupeň PD: PDPS; Název výkresu: PROPUSTEK; Příloha č.: 2; Část: D.1.5; Datum PD: 10.2024; Místo: Pardubický kraj/ Pardubice - Dašice; Souřadnicový systém: S-JTSK; Výškový systém: Bpv

# IfcSite (3)
Name | DisplayName | FingerPrint | IsReferenceObject = IsReferenceStale = IsReferenceSubObject = IsReferenceValid = IsUsed = HasSaveVersionOverride = IsCancelling = IsErased = IsEraseStatusToggled = IsModified = IsModifiedGraphics = IsModifiedXData = IsNewObject = IsNotifyEnabled = IsNotifying = IsObjectIdsInFlux = IsReallyClosing = IsUndoing = AutoDelete = IsDisposed = IsHighlighting = NeedsPromoting = SupportsBaseCurveCommands = SupportsProfileCommands = SwappingReferences = Closed = IsPeriodic = IsPlanar = HasFields = IsAProxy | Name | ShowToolTip = CloneMeForDragging = ForceAnnoAllVisible = IsPersistent = IsReadEnabled = IsTransactionResident = IsWriteEnabled = Visible = CastShadows = ReceiveShadows | StyleName | Bounds | TypeIcon | ColorIndex | Layer | Linetype = PlotStyleName = Material | LinetypeScale | BlockName
UnknownName
Staveniště 1 | Parcela | 0 | no | Staveniště 1 | yes | Parcela KN | ((0,0,0),(0,0,0)) | (Ikona) | 256 | 100-pomocne | ByLayer | 1 | *Model_Space
so 105.6 vykop | Parcela | 0 | no | so 105.6 vykop | yes | Parcela KN | ((0,0,0),(0,0,0)) | (Ikona) | 256 | 100-pomocne | ByLayer | 1 | *Model_Space

# IfcBuiltElement (8)
In: UnknownName
Properties - CloneMeForDragging: yes; ForceAnnoAllVisible: yes; HasSaveVersionOverride: no; IsCancelling: no; IsErased: no; IsEraseStatusToggled: no; IsModified: no; IsModifiedGraphics: no; IsModifiedXData: no; IsNewObject: no; IsNotifyEnabled: no; IsNotifying: no; IsObjectIdsInFlux: no; IsPersistent: yes; IsReadEnabled: yes; IsReallyClosing: no; IsTransactionResident: yes; IsUndoing: no; IsWriteEnabled: yes; AutoDelete: no; IsDisposed: no; IsNull: no; UsesGraphicsCache: yes
Misc - BlockName: *Model_Space; HasFields: no; IsAProxy: no
3D Visualization - CastShadows: yes; Material: ByLayer; ReceiveShadows: yes
General - Linetype: ByLayer; LinetypeScale: 1; Visible: yes
Geometry - IsPlanar: no
CZ_I1 - Označení stavebního objektu: SO 105; Označení podobjektu: SO 105.3; Označení části objektu: nerelevantni; Fáze projektu: PDPS; Název stavebního objektu: Přeložka silnice II/322; Klasifikační systém: OTSKP
CZ_E1 - Datum zahájení prací: 01.05.2025; Datum dokončení: 30.06.2027; Doba trvání: 790; Datum uvedení do provozu: 01.07.2027; Stavební postup / etapa výstavby: nerelevantni
CZ_F1 - Fáze: trvalý stav
Name | Area | NumChanges | RecordHistory = ShowHistory | Bounds | ColorIndex | Layer | PlotStyleName | Staničení od | Staničení do | Označení elementu | Skupina elementů | Označení položky | Označení šablony vlastností | Materiál | specifikace | podrobná specifikace | CZ_S1, Reference | Textura / barva | Skupina přesnosti | Objem | Způsob stanovení objemu
propustky-zpevnění dlažbou | 110.128 | 2 | yes | ((-641578.812425744,-1063381.50487778,229.72),(-641565.16967907,-1063358.79340305,231.405702147749)) | 8 | propustky-zpevnění dlažbou | Barva_8 | 2.1545 | 2.1595 | zpevnění dlažbou | propustky | 465512 | I1+S1+E1+Z1+M2+F1 | lomový kámen | tl. 200 mm správáno MC25 XF4 | nerelevantni | D.1.5.2 | 128;128;128 | P50 | CZ_M2 - Plocha: 45.3547; Způsob stanovení plochy: 3D plocha TIN povrchu
propustky-lože | 104.325 | 2 | yes | ((-641578.812425744,-1063381.50487778,229.62),(-641565.16967907,-1063358.79340305,231.205702147749)) | 16 | propustky-lože | Barva_16 | 2.1545 | 2.1595 | lože | propustky | 45131A | I1+S1;4+E1+Z1+M3+F1 | beton | nerelevantni | nerelevantni | D.1.5.2 | 128;0;0 | P50 | 4.52872 | řezová metoda | CZ_S4 - Beton: C20/25nXF3; Specifikace: nerelevantni; Typ betonářské vyztuže: nerelevantni; Množství betonářské výztuže na m3: 0; Množství betonářské výztuže: 0; Typ předpínací vyztuže: nerelevantni; Množství předpínací výztuže: 0; Referencované výkresy: D.1.5.2; Návrhová životnost: 25 let
propustky-podkladní vrstva | 104.283 | 2 | yes | ((-641578.812425744,-1063381.50487778,229.52),(-641565.16967907,-1063358.79340305,231.105702147749)) | 2 | propustky-podkladní vrstva | Barva_2 | 2.1545 | 2.1595 | podkladní vrstva | propustky | 45157 | I1+S1+E1+Z1+M3+F1 | ŠP | nerelevantni | nerelevantni | D.1.5.2 | 255;255;0 | P50 | 4.5319 | řezová metoda
propustky-obetonování | 80.589 | 1 | no | ((-641576.146003945,-1063376.89352631,229.15002381641),(-641567.356232435,-1063360.46244134,230.538708599649)) | 8 | propustky-obetonování | Barva_8 | 2.15622 | 2.15778 | obetonování | propustky | 45131A | I1+S1+E1+Z1+M3+F1 | beton | C20/25nXF3 | nerelevantni | D.1.5.2 | 128;128;128 | P50 | 12.099 | řezová metoda
propustky-podkladní vrstva | 81.6007 | 1 | no | ((-641576.374211832,-1063377.00320664,229.00002381641),(-641567.129781452,-1063360.35651706,230.05)) | 2 | propustky-podkladní vrstva | Barva_2 | 2.15597 | 2.15803 | podkladní vrstva | propustky | 45157 | I1+S1+E1+Z1+M3+F1 | ŠP | nerelevantni | nerelevantni | D.1.5.2 | 255;255;0 | P50 | 4.98959 | řezová metoda
propustky-zásypy a obsypy | 143.657 | 1 | no | ((-641576.550357206,-1063377.08268049,229.00002381641),(-641566.950254205,-1063360.25536421,231.229430008154)) | 40 | propustky-zásypy a obsypy | Barva_40 | 2.1555 | 2.1585 | zásypy a obsypy | propustky | 45157 | I1+S1;3+E1+Z1+M3+F1 | ŠP | nerelevantni | nerelevantni | D.1.5.2 | 255;165;0 | P50 | 30.3158 | řezová metoda | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni
propustky-propust | 65.9227 | 1 | no | ((-641575.141776669,-1063375.6648759,230.055817724613),(-641568.345283937,-1063361.66903361,230.933041701601)) | 8 | propustky-propust | Barva_8 | 2.1566 | 2.1574 | propust | propustky | 87460 | I1+S1;2+E1+Z1+M1+F1 | PP SN16 | nerelevantni | nerelevantni | D.1.5.2 | 128;128;128 | P10 | CZ_M1 - Délka: 17.4; Způsob stanovení délky: Délka 3D křivky; CZ_S2 - Reference: D.1.5.2; Typ stavebního výrobku: propustek; Stavební výrobek: potrubí; Specifikace: PP SN16 DN800; Podrobná specifikace: nerelevantni; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni
zemní práce-výkop_odkop | 116.535 | 3 | no | ((-641576.577912425,-1063377.0996883,229.00002381641),(-641566.747634272,-1063360.17468708,230.530502888384)) | 36 | zemní práce-výkop_odkop | Barva_36 | 2.1555 | 2.1585 | výkop/odkop | zemní práce | 13173 | I1+S3+E1+Z1+M3+F1 |  |  |  |  | 125;75;0 | P100 | 30.9719 | řezová metoda | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni
