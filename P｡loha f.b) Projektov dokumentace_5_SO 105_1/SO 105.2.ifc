Properties of the parts of a building model (IFC4X3_ADD2)

# File
Description: ViewDefinition [Ifc4X3NotAssigned]
File name: D:\_Projekty\2017_07 - SÚS Obchvat Dašic\4_PDPS\BIM\IFC\SO 105.2.ifc
Time: 2025-05-05T10:00:19
Author: Michal Švarc
Organization: DESKTOP-47J51D1
Written by: GeometryGymIFCcore v24.8.23.0 by Geometry Gym Pty Ltd built 2024-08-23T03:53:20
Made in: Civil 3D 2024 IfcInfra Plugin v13.6.170.0
Comment: name
Comment: time_stamp
Comment: author
Comment: organization
Comment: preprocessor_version
Comment: originating_system
Comment: authorization

# IfcProject, SO 105
Summary - Title: CAD Studio Silniční šablona; Author: Martin Folber, Ondřej Vojtěchovský, Jakub Kareš; HyperlinkBase: www.cadstudio.cz
Custom_Properties - Investor: Správa a údržba silnic Pardubického kraje, Doubravice 98, 533 53 Pardubice; Zakázka: přeložka silnice II/322 Černá za Bory - Dašice; Stupeň PD: PDPS; Název výkresu: PROPUSTEK; Příloha č.: 2; Část: D.1.5; Datum PD: 10.2024; Místo: Pardubický kraj/ Pardubice - Dašice; Souřadnicový systém: S-JTSK; Výškový systém: Bpv

# IfcSite (3)
Name | DisplayName | FingerPrint | IsReferenceObject = IsReferenceStale = IsReferenceSubObject = IsReferenceValid = IsUsed = HasSaveVersionOverride = IsCancelling = IsErased = IsEraseStatusToggled = IsModified = IsModifiedGraphics = IsModifiedXData = IsNewObject = IsNotifyEnabled = IsNotifying = IsObjectIdsInFlux = IsReallyClosing = IsUndoing = AutoDelete = IsDisposed = IsHighlighting = NeedsPromoting = SupportsBaseCurveCommands = SupportsProfileCommands = SwappingReferences = Closed = IsPeriodic = IsPlanar = HasFields = IsAProxy | Name | ShowToolTip = CloneMeForDragging = ForceAnnoAllVisible = IsPersistent = IsReadEnabled = IsTransactionResident = IsWriteEnabled = Visible = CastShadows = ReceiveShadows | StyleName | Bounds | TypeIcon | ColorIndex | Layer | Linetype = PlotStyleName = Material | LinetypeScale | BlockName
UnknownName
Staveniště 1 | Parcela | 0 | no | Staveniště 1 | yes | Parcela KN | ((0,0,0),(0,0,0)) | (Ikona) | 256 | 100-pomocne | ByLayer | 1 | *Model_Space
so 105.6 vykop | Parcela | 0 | no | so 105.6 vykop | yes | Parcela KN | ((0,0,0),(0,0,0)) | (Ikona) | 256 | 100-pomocne | ByLayer | 1 | *Model_Space

# IfcBuiltElement (16)
In: UnknownName
Properties - CloneMeForDragging: yes; ForceAnnoAllVisible: yes; HasSaveVersionOverride: no; IsCancelling: no; IsErased: no; IsEraseStatusToggled: no; IsModifiedXData: no; IsNewObject: no; IsNotifyEnabled: no; IsNotifying: no; IsObjectIdsInFlux: no; IsPersistent: yes; IsReadEnabled: yes; IsReallyClosing: no; IsTransactionResident: yes; IsUndoing: no; IsWriteEnabled: yes; AutoDelete: no; IsDisposed: no; IsNull: no; UsesGraphicsCache: yes
Misc - BlockName: *Model_Space; HasFields: no; IsAProxy: no
3D Visualization - CastShadows: yes; Material: ByLayer; ReceiveShadows: yes
General - Linetype: ByLayer; LinetypeScale: 1; Visible: yes
Geometry - IsPlanar: no
CZ_F1 - Fáze: trvalý stav
CZ_I1 - Označení stavebního objektu: SO 105; Označení podobjektu: SO 105.2; Označení části objektu: nerelevantni; Fáze projektu: PDPS; Název stavebního objektu: Přeložka silnice II/322; Klasifikační systém: OTSKP
CZ_S1 - podrobná specifikace: nerelevantni; Reference: D.1.5.2
CZ_E1 - Datum zahájení prací: 01.05.2025; Datum dokončení: 30.06.2027; Doba trvání: 790; Datum uvedení do provozu: 01.07.2027; Stavební postup / etapa výstavby: nerelevantni
Name | Area | NumChanges | RecordHistory = ShowHistory = IsModified = IsModifiedGraphics | Bounds | ColorIndex | Layer | PlotStyleName | Staničení od | Staničení do | Označení elementu | Skupina elementů | Označení položky | Označení šablony vlastností | Materiál | specifikace | Textura / barva | Skupina přesnosti | Objem | Způsob stanovení objemu
propustky-obetonování | 13.6005 | 2 | yes | ((-642409.261974297,-1062986.36510601,228.79),(-642406.722686864,-1062983.33645312,230.143328231178)) | 8 | propustky-obetonování | Barva_8 | 1.23622 | 1.23778 | obetonování | propustky | 45131A | I1+S1+E1+Z1+M3+F1 | beton | C20/25nXF3 | 128;128;128 | P50 | 1.56223 | řezová metoda
propustky-podkladní vrstva | 91.5591 | 1 | no | ((-642409.487139344,-1062986.47373705,228.64),(-642398.912340398,-1062967.50563249,230.045521541185)) | 2 | propustky-podkladní vrstva | Barva_2 | 1.23597 | 1.23803 | podkladní vrstva | propustky | 45157 | I1+S1+E1+Z1+M3+F1 | ŠP | nerelevantni | 255;255;0 | P50 | 5.74949 | řezová metoda
propustky-zásypy a obsypy | 151.767 | 1 | no | ((-642409.780883746,-1062986.6113085,228.64),(-642398.72968991,-1062967.41567997,231.145521541185)) | 40 | propustky-zásypy a obsypy | Barva_40 | 1.23559 | 1.23841 | zásypy a obsypy | propustky | 45157 | I1+S1;3+E1+Z1+M3+F1 | ŠP | nerelevantni | 255;165;0 | P50 | 31.034 | řezová metoda | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni
propustky-zpevnění dlažbou | 30.7722 | 2 | yes | ((-642411.46675879,-1062990.26200305,229.44),(-642406.289480495,-1062984.83924912,229.94)) | 8 | propustky-zpevnění dlažbou | Barva_8 | 1.2345 | 1.2395 | zpevnění dlažbou | propustky | 465512 | I1+S1+E1+Z1+M2+F1 | lomový kámen | tl. 200 mm správáno MC25 XF4 | 128;128;128 | P50 | CZ_M2 - Plocha: 13.6368; Způsob stanovení plochy: 3D plocha TIN povrchu
propustky-lože | 29.0229 | 2 | yes | ((-642411.46675879,-1062990.26200305,229.34),(-642406.289480495,-1062984.83924912,229.74)) | 16 | propustky-lože | Barva_16 | 1.2345 | 1.2395 | lože | propustky | 45131A | I1+S1;4+E1+Z1+M3+F1 | beton | nerelevantni | 128;0;0 | P50 | 1.34069 | řezová metoda | CZ_S4 - Beton: C20/25nXF3; Specifikace: nerelevantni; Typ betonářské vyztuže: nerelevantni; Množství betonářské výztuže na m3: 0; Množství betonářské výztuže: 0; Typ předpínací vyztuže: nerelevantni; Množství předpínací výztuže: 0; Referencované výkresy: D.1.5.2; Návrhová životnost: 25 let
propustky-podkladní vrstva | 29.0229 | 2 | yes | ((-642411.46675879,-1062990.26200305,229.24),(-642406.289480495,-1062984.83924912,229.64)) | 2 | propustky-podkladní vrstva | Barva_2 | 1.2345 | 1.2395 | podkladní vrstva | propustky | 45157 | I1+S1+E1+Z1+M3+F1 | ŠP | nerelevantni | 255;255;0 | P50 | 1.34069 | řezová metoda
založení-patka _ pás | 5.55045 | 2 | yes | ((-642411.640568446,-1062990.62226713,229.04),(-642409.215108323,-1062989.1756927,229.94)) | 6 | založení-patka _ pás | Barva_6 | 1.23575 | 1.23825 | patka / pás | založení | 467314 | I1+S1;4+E1+Z1+M3+F1 | beton | nerelevantni | 255;0;255 | P10 | 0.6 | řezová metoda | CZ_S4 - Beton: C25/30 XF3; Specifikace: nerelevantni; Typ betonářské vyztuže: nerelevantni; Množství betonářské výztuže na m3: 0; Množství betonářské výztuže: 0; Typ předpínací vyztuže: nerelevantni; Množství předpínací výztuže: 0; Referencované výkresy: D.1.5.2; Návrhová životnost: 25 let
propustky-zpevnění dlažbou | 26.0697 | 2 | yes | ((-642410.762509366,-1062987.07461626,229.49),(-642406.198523783,-1062982.88781532,231.020484555384)) | 8 | propustky-zpevnění dlažbou | Barva_8 | 1.2345 | 1.2395 | zpevnění dlažbou | propustky | 465512 | I1+S1+E1+Z1+M2+F1 | lomový kámen | tl. 200 mm správáno MC25 XF4 | 128;128;128 | P50 | CZ_M2 - Plocha: 10.0546; Způsob stanovení plochy: 3D plocha TIN povrchu
propustky-lože | 23.9853 | 1 | no | ((-642410.764334326,-1062987.0737358,229.390020530497),(-642406.200348743,-1062982.88693487,230.82050508588)) | 16 | propustky-lože | Barva_16 | 1.2345 | 1.2395 | lože | propustky | 45131A | I1+S1;4+E1+Z1+M3+F1 | beton | nerelevantni | 128;0;0 | P50 | 1.01653 | řezová metoda | CZ_S4 - Beton: C20/25nXF3; Specifikace: nerelevantni; Typ betonářské vyztuže: nerelevantni; Množství betonářské výztuže na m3: 0; Množství betonářské výztuže: 0; Typ předpínací vyztuže: nerelevantni; Množství předpínací výztuže: 0; Referencované výkresy: D.1.5.2; Návrhová životnost: 25 let
propustky-podkladní vrstva | 23.9853 | 1 | no | ((-642410.765246806,-1062987.07329558,229.290030795745),(-642406.201261223,-1062982.88649464,230.720515351129)) | 2 | propustky-podkladní vrstva | Barva_2 | 1.2345 | 1.2395 | podkladní vrstva | propustky | 45157 | I1+S1+E1+Z1+M3+F1 | ŠP | nerelevantni | 255;255;0 | P50 | 1.01653 | řezová metoda
propustky-zpevnění dlažbou | 41.503 | 1 | no | ((-642402.743967809,-1062971.18285291,229.9),(-642397.046112891,-1062965.86135977,231.514643221209)) | 8 | propustky-zpevnění dlažbou | Barva_8 | 1.2345 | 1.2395 | zpevnění dlažbou | propustky | 465512 | I1+S1+E1+Z1+M2+F1 | lomový kámen | tl. 200 mm správáno MC25 XF4 | 128;128;128 | P50 | CZ_M2 - Plocha: 17.721; Způsob stanovení plochy: 3D plocha TIN povrchu
propustky-lože | 39.1691 | 1 | no | ((-642402.743967809,-1062971.18285291,229.8),(-642397.046112891,-1062965.86135977,231.314643221209)) | 16 | propustky-lože | Barva_16 | 1.2345 | 1.2395 | lože | propustky | 45131A | I1+S1;4+E1+Z1+M3+F1 | beton | nerelevantni | 128;0;0 | P50 | 1.74491 | řezová metoda | CZ_S4 - Beton: C20/25nXF3; Specifikace: nerelevantni; Typ betonářské vyztuže: nerelevantni; Množství betonářské výztuže na m3: 0; Množství betonářské výztuže: 0; Typ předpínací vyztuže: nerelevantni; Množství předpínací výztuže: 0; Referencované výkresy: D.1.5.2; Návrhová životnost: 25 let
propustky-podkladní vrstva | 39.1691 | 1 | no | ((-642402.743967809,-1062971.18285291,229.7),(-642397.046112891,-1062965.86135977,231.214643221209)) | 2 | propustky-podkladní vrstva | Barva_2 | 1.2345 | 1.2395 | podkladní vrstva | propustky | 45157 | I1+S1+E1+Z1+M3+F1 | ŠP | nerelevantni | 255;255;0 | P50 | 1.74491 | řezová metoda
propustky-propust | 88.6035 | 1 | no | ((-642408.684940143,-1062986.04131595,229.689997444216),(-642399.72116955,-1062967.97345716,230.861474172451)) | 8 | propustky-propust | Barva_8 | 1.2366 | 1.2374 | propust | propustky | 87460 | I1+S1;2+E1+Z1+M1+F1 | PP SN16 | nerelevantni | 128;128;128 | P10 | CZ_M1 - Délka: 20.05; Způsob stanovení délky: Délka 3D křivky; CZ_S2 - Reference: D.1.5.2; Typ stavebního výrobku: propustek; Stavební výrobek: potrubí; Specifikace: PP SN16 DN800; Podrobná specifikace: nerelevantni; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni
propustky-obetonování | 13.6751 | 2 | yes | ((-642401.701254263,-1062970.69361877,229.192720090618),(-642399.137505445,-1062967.61426353,230.462554766882)) | 8 | propustky-obetonování | Barva_8 | 1.23622 | 1.23778 | obetonování | propustky | 45131A | I1+S1+E1+Z1+M3+F1 | beton | C20/25nXF3 | 128;128;128 | P50 | 1.7478 | řezová metoda
propustky-zásypy a obsypy | 59.5659 | 2 | yes | ((-642408.127866292,-1062984.01438293,229.743328231178),(-642400.296074835,-1062970.01568896,230.445521541185)) | 40 | propustky-zásypy a obsypy | Barva_40 | 1.23622 | 1.23778 | zásypy a obsypy | propustky | 45157 | I1+S1;3+E1+Z1+M3+F1 | ŠP | nerelevantni | 255;165;0 | P50 | 3.87968 | řezová metoda | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni
