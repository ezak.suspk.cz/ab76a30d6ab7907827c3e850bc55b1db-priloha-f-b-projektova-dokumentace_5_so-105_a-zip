Properties of the parts of a building model (IFC4X3_ADD2)

# File
Description: ViewDefinition [Ifc4X3NotAssigned]
File name: D:\_Projekty\2017_07 - SÚS Obchvat Dašic\4_PDPS\BIM\IFC\SO 105.1.ifc
Time: 2025-05-05T09:56:44
Author: Michal Švarc
Organization: DESKTOP-47J51D1
Written by: GeometryGymIFCcore v24.8.23.0 by Geometry Gym Pty Ltd built 2024-08-23T03:53:20
Made in: Civil 3D 2024 IfcInfra Plugin v13.6.170.0
Comment: name
Comment: time_stamp
Comment: author
Comment: organization
Comment: preprocessor_version
Comment: originating_system
Comment: authorization

# IfcProject, SO 105
Summary - Title: CAD Studio Silniční šablona; Author: Martin Folber, Ondřej Vojtěchovský, Jakub Kareš; HyperlinkBase: www.cadstudio.cz
Custom_Properties - Investor: Správa a údržba silnic Pardubického kraje, Doubravice 98, 533 53 Pardubice; Zakázka: přeložka silnice II/322 Černá za Bory - Dašice; Stupeň PD: PDPS; Název výkresu: PROPUSTEK; Příloha č.: 2; Část: D.1.5; Datum PD: 10.2024; Místo: Pardubický kraj/ Pardubice - Dašice; Souřadnicový systém: S-JTSK; Výškový systém: Bpv

# IfcSite (3)
Name | DisplayName | FingerPrint | IsReferenceObject = IsReferenceStale = IsReferenceSubObject = IsReferenceValid = IsUsed = HasSaveVersionOverride = IsCancelling = IsErased = IsEraseStatusToggled = IsModified = IsModifiedGraphics = IsModifiedXData = IsNewObject = IsNotifyEnabled = IsNotifying = IsObjectIdsInFlux = IsReallyClosing = IsUndoing = AutoDelete = IsDisposed = IsHighlighting = NeedsPromoting = SupportsBaseCurveCommands = SupportsProfileCommands = SwappingReferences = IsPeriodic = IsPlanar = HasFields = IsAProxy | Name | ShowToolTip = CloneMeForDragging = ForceAnnoAllVisible = IsPersistent = IsReadEnabled = IsTransactionResident = IsWriteEnabled = Visible = CastShadows = ReceiveShadows | StyleName | Bounds | TypeIcon | ColorIndex | Layer | Linetype = PlotStyleName = Material | LinetypeScale | Closed | BlockName
UnknownName
Staveniště 1 | Parcela | 0 | no | Staveniště 1 | yes | Parcela KN | ((-642692.289894617,-1062842.30506922,229.812240267638),(-642668.668190299,-1062814.36135091,230.51099930238)) | (Ikona) | 256 | 100-pomocne | ByLayer | 1 | yes | *Model_Space
so 105.6 vykop | Parcela | 0 | no | so 105.6 vykop | yes | Parcela KN | ((0,0,0),(0,0,0)) | (Ikona) | 256 | 100-pomocne | ByLayer | 1 | no | *Model_Space

# IfcBuiltElement (19)
In: UnknownName
Properties - CloneMeForDragging: yes; ForceAnnoAllVisible: yes; HasSaveVersionOverride: no; IsCancelling: no; IsErased: no; IsEraseStatusToggled: no; IsModified: no; IsModifiedGraphics: no; IsModifiedXData: no; IsNewObject: no; IsNotifyEnabled: no; IsNotifying: no; IsObjectIdsInFlux: no; IsPersistent: yes; IsReadEnabled: yes; IsReallyClosing: no; IsTransactionResident: yes; IsUndoing: no; IsWriteEnabled: yes; AutoDelete: no; IsDisposed: no; IsNull: no; UsesGraphicsCache: yes
Misc - BlockName: *Model_Space; HasFields: no; IsAProxy: no
3D Visualization - CastShadows: yes; Material: ByLayer; ReceiveShadows: yes
General - Linetype: ByLayer; LinetypeScale: 1; Visible: yes
Geometry - IsPlanar: no
CZ_I1 - Označení stavebního objektu: SO 105; Označení podobjektu: SO 105.1; Označení části objektu: nerelevantni; Fáze projektu: PDPS; Název stavebního objektu: Přeložka silnice II/322; Klasifikační systém: OTSKP
CZ_E1 - Datum zahájení prací: 01.05.2025; Datum dokončení: 30.06.2027; Doba trvání: 790; Datum uvedení do provozu: 01.07.2027; Stavební postup / etapa výstavby: nerelevantni
CZ_F1 - Fáze: trvalý stav
Name | Area | NumChanges | RecordHistory = ShowHistory | Bounds | ColorIndex | Layer | PlotStyleName | Staničení od | Staničení do | Označení elementu | Skupina elementů | Označení položky | Označení šablony vlastností | Materiál | specifikace | podrobná specifikace | CZ_S1, Reference | Textura / barva | Skupina přesnosti | Objem | Způsob stanovení objemu
propustky-zpevnění dlažbou | 32.3449 | 1 | no | ((-642690.399071909,-1062841.26127438,229.583999999989),(-642670.458698017,-1062815.28028494,230.48)) | 8 | propustky-zpevnění dlažbou | Barva_8 | 0.92174 | 0.92428 | zpevnění dlažbou | propustky | 465512 | I1+S1+E1+Z1+M2+F1 | lomový kámen | tl. 200 mm správáno MC25 XF4 | nerelevantni | D.1.5.2 | 128;128;128 | P50 | CZ_M2 - Plocha: 14.1004; Způsob stanovení plochy: 3D plocha TIN povrchu
propustky-lože | 30.2729 | 1 | no | ((-642690.399071909,-1062841.26127438,229.483999999989),(-642670.458698017,-1062815.28028494,230.28)) | 16 | propustky-lože | Barva_16 | 0.92174 | 0.92428 | lože | propustky | 45131A | I1+S1;4+E1+Z1+M3+F1 | beton | nerelevantni | nerelevantni | D.1.5.2 | 128;0;0 | P50 | 1.34 | řezová metoda | CZ_S4 - Beton: C20/25nXF3; Specifikace: nerelevantni; Typ betonářské vyztuže: nerelevantni; Množství betonářské výztuže na m3: 0; Množství betonářské výztuže: 0; Typ předpínací vyztuže: nerelevantni; Množství předpínací výztuže: 0; Referencované výkresy: D.1.5.2; Návrhová životnost: 25 let
propustky-podkladní vrstva | 30.2729 | 1 | no | ((-642690.399071909,-1062841.26127438,229.383999999989),(-642670.458698017,-1062815.28028494,230.18)) | 2 | propustky-podkladní vrstva | Barva_2 | 0.92174 | 0.92428 | podkladní vrstva | propustky | 45157 | I1+S1+E1+Z1+M3+F1 | ŠP | nerelevantni | nerelevantni | D.1.5.2 | 255;255;0 | P50 | 1.34 | řezová metoda
založení-patka _ pás | 5.57418 | 2 | yes | ((-642690.635121968,-1062841.58419909,229.18),(-642688.380792459,-1062839.78596151,230.130000000015)) | 6 | založení-patka _ pás | Barva_6 | 0.92177 | 0.92423 | patka / pás | založení | 467314 | I1+S1;4+E1+Z1+M3+F1 | beton | nerelevantni | nerelevantni | D.1.5.2 | 255;0;255 | P10 | 0.6 | řezová metoda | CZ_S4 - Beton: C25/30 XF3; Specifikace: nerelevantni; Typ betonářské vyztuže: nerelevantni; Množství betonářské výztuže na m3: 0; Množství betonářské výztuže: 0; Typ předpínací vyztuže: nerelevantni; Množství předpínací výztuže: 0; Referencované výkresy: D.1.5.2; Návrhová životnost: 25 let
založení-patka _ pás | 5.57825 | 2 | yes | ((-642672.476977468,-1062816.75559781,229.519873417725),(-642670.222647958,-1062814.95736023,230.48)) | 6 | založení-patka _ pás | Barva_6 | 0.92174 | 0.92428 | patka / pás | založení | 467314 | I1+S1;4+E1+Z1+M3+F1 | beton | nerelevantni | nerelevantni | D.1.5.2 | 255;0;255 | P10 | 0.6 | řezová metoda | CZ_S4 - Beton: C25/30 XF3; Specifikace: nerelevantni; Typ betonářské vyztuže: nerelevantni; Množství betonářské výztuže na m3: 0; Množství betonářské výztuže: 0; Typ předpínací vyztuže: nerelevantni; Množství předpínací výztuže: 0; Referencované výkresy: D.1.5.2; Návrhová životnost: 25 let
odvodnění-podkladní beton | 23.74 | 2 | yes | ((-642676.316366548,-1062820.96703132,228.91),(-642670.065627226,-1062815.75878784,229.01)) | 9 | odvodnění-podkladní beton | Barva_9 | 0.91971 | 0.92629 | podkladní beton | odvodnění | 451312 | I1+S1+E1+Z1+M3+F1 | beton | C12/15 | nereleventani | D.1.5.2 | 191;191;191 | P100 | 1.105 | řezová metoda
založení-patka _ pás | 25.2 | 2 | yes | ((-642675.967007316,-1062820.61767209,229.01),(-642670.414986458,-1062816.10814707,229.76)) | 6 | založení-patka _ pás | Barva_6 | 0.91996 | 0.92604 | patka / pás | založení | 272314 | I1+S1;4+E1+Z1+M3+F1 | beton | nerelevantni | nerelevantni | D.1.5.2 | 255;0;255 | P10 | 5.4 | řezová metoda | CZ_S4 - Beton: C25/30 XF3; Specifikace: nerelevantni; Typ betonářské vyztuže: nerelevantni; Množství betonářské výztuže na m3: 0; Množství betonářské výztuže: 0; Typ předpínací vyztuže: nerelevantni; Množství předpínací výztuže: 0; Referencované výkresy: D.1.5.2; Návrhová životnost: 25 let
propustky-čelo | 29.4581 | 2 | yes | ((-642675.967007316,-1062820.61767209,229.76),(-642670.680542774,-1062816.47143737,231.21)) | 9 | propustky-čelo | Barva_9 | 0.91997 | 0.92603 | čelo | propustky | 918115 | I1+S1;4+E1+Z1+M3;4+F1 | beton | nerelevantni | nerelevantni | D.1.5.2 | 191;191;191 | P50 | 6.15043 | řezová metoda | CZ_S4 - Beton: C30/37 XF4+XD3; Specifikace: nerelevantni; Typ betonářské vyztuže: nerelevantni; Množství betonářské výztuže na m3: 0; Množství betonářské výztuže: 0; Typ předpínací vyztuže: nerelevantni; Množství předpínací výztuže: 0; Referencované výkresy: D.1.5.2; Návrhová životnost: 25 let; CZ_M4 - Počet: 1; Způsob stanovení počtu: výpočet z délky
propustky-čelo | 13.7964 | 2 | yes | ((-642675.967007316,-1062820.61767209,231.209999999963),(-642670.620471372,-1062816.3892576,231.581794340396)) | 9 | propustky-čelo | Barva_9 | 0.91996 | 0.92604 | čelo | propustky | 918115 | I1+S1;4+E1+Z1+M3;4+F1 | beton | nerelevantni | nerelevantni | D.1.5.2 | 191;191;191 | P50 | 1.41219 | řezová metoda | CZ_S4 - Beton: C30/37 XF4+XD3; Specifikace: nerelevantni; Typ betonářské vyztuže: nerelevantni; Množství betonářské výztuže na m3: 0; Množství betonářské výztuže: 0; Typ předpínací vyztuže: nerelevantni; Množství předpínací výztuže: 0; Referencované výkresy: D.1.5.2; Návrhová životnost: 25 let; CZ_M4 - Počet: 1; Způsob stanovení počtu: výpočet z délky
odvodnění-podkladní beton | 23.74 | 2 | yes | ((-642690.89245769,-1062840.90763229,228.66),(-642684.641718368,-1062835.69938881,228.76)) | 9 | odvodnění-podkladní beton | Barva_9 | 0.9198 | 0.9262 | podkladní beton | odvodnění | 451312 | I1+S1+E1+Z1+M3+F1 | beton | C12/15 | nereleventani | D.1.5.2 | 191;191;191 | P100 | 1.105 | řezová metoda
založení-patka _ pás | 25.2 | 2 | yes | ((-642690.543098458,-1062840.55827306,228.76),(-642684.9910776,-1062836.04874804,229.51)) | 6 | založení-patka _ pás | Barva_6 | 0.92004 | 0.92596 | patka / pás | založení | 272314 | I1+S1;4+E1+Z1+M3+F1 | beton | nerelevantni | nerelevantni | D.1.5.2 | 255;0;255 | P10 | 5.4 | řezová metoda | CZ_S4 - Beton: C25/30 XF3; Specifikace: nerelevantni; Typ betonářské vyztuže: nerelevantni; Množství betonářské výztuže na m3: 0; Množství betonářské výztuže: 0; Typ předpínací vyztuže: nerelevantni; Množství předpínací výztuže: 0; Referencované výkresy: D.1.5.2; Návrhová životnost: 25 let
propustky-čelo | 28.1081 | 2 | yes | ((-642690.277542141,-1062840.19498276,229.51),(-642684.9910776,-1062836.04874804,230.86)) | 9 | propustky-čelo | Barva_9 | 0.92004 | 0.92596 | čelo | propustky | 918115 | I1+S1;4+E1+Z1+M3;4+F1 | beton | nerelevantni | nerelevantni | D.1.5.2 | 191;191;191 | P50 | 5.70043 | řezová metoda | CZ_S4 - Beton: C30/37 XF4+XD3; Specifikace: nerelevantni; Typ betonářské vyztuže: nerelevantni; Množství betonářské výztuže na m3: 0; Množství betonářské výztuže: 0; Typ předpínací vyztuže: nerelevantni; Množství předpínací výztuže: 0; Referencované výkresy: D.1.5.2; Návrhová životnost: 25 let; CZ_M4 - Počet: 1; Způsob stanovení počtu: výpočet z délky
propustky-čelo | 13.7964 | 2 | yes | ((-642690.337613543,-1062840.27716253,230.85999999987),(-642684.9910776,-1062836.04874804,231.231794340303)) | 9 | propustky-čelo | Barva_9 | 0.92004 | 0.92596 | čelo | propustky | 918115 | I1+S1;4+E1+Z1+M3;4+F1 | beton | nerelevantni | nerelevantni | D.1.5.2 | 191;191;191 | P50 | 1.41219 | řezová metoda | CZ_S4 - Beton: C30/37 XF4+XD3; Specifikace: nerelevantni; Typ betonářské vyztuže: nerelevantni; Množství betonářské výztuže na m3: 0; Množství betonářské výztuže: 0; Typ předpínací vyztuže: nerelevantni; Množství předpínací výztuže: 0; Referencované výkresy: D.1.5.2; Návrhová životnost: 25 let; CZ_M4 - Počet: 1; Způsob stanovení počtu: výpočet z délky
propustky-zásypy a obsypy | 203.176 | 2 | yes | ((-642688.54735301,-1062838.6482983,229.667199999986),(-642672.410731906,-1062818.01812183,231.142799999997)) | 40 | propustky-zásypy a obsypy | Barva_40 | 0.92158 | 0.92442 | zásypy a obsypy | propustky | 45157 | I1+S1;3+E1+Z1+M3+F1 | ŠP | nerelevantni | nerelevantni | D.1.5.2 | 255;165;0 | P50 | 46.8986 | řezová metoda | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni
propustky-podkladní vrstva | 100.322 | 2 | yes | ((-642688.243888184,-1062838.42651796,229.66720574837),(-642672.713473823,-1062818.23941876,230.042800000093)) | 2 | propustky-podkladní vrstva | Barva_2 | 0.92196 | 0.92404 | podkladní vrstva | propustky | 45157 | I1+S1+E1+Z1+M3+F1 | ŠP | nerelevantni | nerelevantni | D.1.5.2 | 255;255;0 | P50 | 6.73307 | řezová metoda
propustky-zásypy a obsypy | 94.3183 | 2 | yes | ((-642688.042105083,-1062838.27892533,229.817206477892),(-642672.915699973,-1062818.38787766,230.442792704804)) | 40 | propustky-zásypy a obsypy | Barva_40 | 0.92221 | 0.92379 | zásypy a obsypy | propustky | 45157 | I1+S1;3+E1+Z1+M3+F1 | ŠP | nerelevantni | nerelevantni | D.1.5.2 | 255;165;0 | P50 | 6.16399 | řezová metoda | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni
propustky-propust | 122.426 | 1 | no | ((-642688.178531513,-1062838.66065738,229.81),(-642672.779553403,-1062818.00576275,230.85)) | 8 | propustky-propust | Barva_8 | 0.9226 | 0.9234 | propust | propustky | 87460 | I1+S1;2+E1+Z1+M1+F1 | PP SN16 | nerelevantni | nerelevantni | D.1.5.2 | 128;128;128 | P10 | CZ_M1 - Délka: 25; Způsob stanovení délky: Délka 3D křivky; CZ_S2 - Reference: D.1.5.2; Typ stavebního výrobku: propustek; Stavební výrobek: potrubí; Specifikace: PP SN16 DN800; Podrobná specifikace: nerelevantni; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni
zemní práce-výkop_odkop | 155.98 | 1 | no | ((-642692.289894617,-1062841.8199641,228.66),(-642668.668190299,-1062814.36135091,230.510999302216)) | 36 | zemní práce-výkop_odkop | Barva_36 | 0.91869 | 0.92731 | výkop/odkop | zemní práce | 12273 | I1+S3+E1+Z1+M3+F1 |  |  |  |  | 125;75;0 | P100 | 57.8924 | řezová metoda | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni
zemní práce-výkop_odkop | 23.9999 | 2 | yes | ((-642692.028314024,-1062843.35523889,230),(-642690.028314024,-1062841.35523889,231.99999279851)) | 36 | zemní práce-výkop_odkop | Barva_36 | 0.91869 | 0.92731 | výkop/odkop | zemní práce | 18215 | I1+S3+E1+Z1+M3+F1 |  |  |  |  | 125;75;0 | P100 | 2075 | řezová metoda | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni
