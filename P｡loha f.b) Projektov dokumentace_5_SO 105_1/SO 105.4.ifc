Properties of the parts of a building model (IFC4X3_ADD2)

# File
Description: ViewDefinition [Ifc4X3NotAssigned]
File name: D:\_Projekty\2017_07 - SÚS Obchvat Dašic\4_PDPS\BIM\IFC\SO 105.4.ifc
Time: 2025-05-05T10:03:54
Author: Michal Švarc
Organization: DESKTOP-47J51D1
Written by: GeometryGymIFCcore v24.8.23.0 by Geometry Gym Pty Ltd built 2024-08-23T03:53:20
Made in: Civil 3D 2024 IfcInfra Plugin v13.6.170.0
Comment: name
Comment: time_stamp
Comment: author
Comment: organization
Comment: preprocessor_version
Comment: originating_system
Comment: authorization

# IfcProject, SO 105
Summary - Title: CAD Studio Silniční šablona; Author: Martin Folber, Ondřej Vojtěchovský, Jakub Kareš; HyperlinkBase: www.cadstudio.cz
Custom_Properties - Investor: Správa a údržba silnic Pardubického kraje, Doubravice 98, 533 53 Pardubice; Zakázka: přeložka silnice II/322 Černá za Bory - Dašice; Stupeň PD: PDPS; Název výkresu: PROPUSTEK; Příloha č.: 2; Část: D.1.5; Datum PD: 10.2024; Místo: Pardubický kraj/ Pardubice - Dašice; Souřadnicový systém: S-JTSK; Výškový systém: Bpv

# IfcSite (3)
Name | DisplayName | FingerPrint | IsReferenceObject = IsReferenceStale = IsReferenceSubObject = IsReferenceValid = IsUsed = HasSaveVersionOverride = IsCancelling = IsErased = IsEraseStatusToggled = IsModified = IsModifiedGraphics = IsModifiedXData = IsNewObject = IsNotifyEnabled = IsNotifying = IsObjectIdsInFlux = IsReallyClosing = IsUndoing = AutoDelete = IsDisposed = IsHighlighting = NeedsPromoting = SupportsBaseCurveCommands = SupportsProfileCommands = SwappingReferences = Closed = IsPeriodic = IsPlanar = HasFields = IsAProxy | Name | ShowToolTip = CloneMeForDragging = ForceAnnoAllVisible = IsPersistent = IsReadEnabled = IsTransactionResident = IsWriteEnabled = Visible = CastShadows = ReceiveShadows | StyleName | Bounds | TypeIcon | ColorIndex | Layer | Linetype = PlotStyleName = Material | LinetypeScale | BlockName
UnknownName
Staveniště 1 | Parcela | 0 | no | Staveniště 1 | yes | Parcela KN | ((0,0,0),(0,0,0)) | (Ikona) | 256 | 100-pomocne | ByLayer | 1 | *Model_Space
so 105.6 vykop | Parcela | 0 | no | so 105.6 vykop | yes | Parcela KN | ((0,0,0),(0,0,0)) | (Ikona) | 256 | 100-pomocne | ByLayer | 1 | *Model_Space

# IfcBuiltElement (10)
In: UnknownName
Properties - CloneMeForDragging: yes; ForceAnnoAllVisible: yes; HasSaveVersionOverride: no; IsCancelling: no; IsErased: no; IsEraseStatusToggled: no; IsModifiedXData: no; IsNewObject: no; IsNotifyEnabled: no; IsNotifying: no; IsObjectIdsInFlux: no; IsPersistent: yes; IsReadEnabled: yes; IsReallyClosing: no; IsTransactionResident: yes; IsUndoing: no; IsWriteEnabled: yes; AutoDelete: no; IsDisposed: no; IsNull: no; UsesGraphicsCache: yes
Misc - BlockName: *Model_Space; HasFields: no; IsAProxy: no
3D Visualization - CastShadows: yes; Material: ByLayer; ReceiveShadows: yes
General - Linetype: ByLayer; LinetypeScale: 1; Visible: yes
Geometry - IsPlanar: no
CZ_I1 - Označení stavebního objektu: SO 105; Označení podobjektu: SO 105.4; Označení části objektu: nerelevantni; Fáze projektu: PDPS; Název stavebního objektu: Přeložka silnice II/322; Klasifikační systém: OTSKP
CZ_S1 - podrobná specifikace: nerelevantni; Reference: D.1.5.2
CZ_E1 - Datum zahájení prací: 01.05.2025; Datum dokončení: 30.06.2027; Doba trvání: 790; Datum uvedení do provozu: 01.07.2027; Stavební postup / etapa výstavby: nerelevantni
CZ_F1 - Fáze: trvalý stav
Name | IsModified = IsModifiedGraphics = RecordHistory = ShowHistory | Area | NumChanges | Bounds | ColorIndex | Layer | PlotStyleName | Staničení od | Staničení do | Označení elementu | Skupina elementů | Označení položky | Označení šablony vlastností | Materiál | specifikace | Textura / barva | Skupina přesnosti | Objem | Způsob stanovení objemu
propustky-zpevnění dlažbou | no | 67.3373 | 1 | ((-640738.129723468,-1063771.17009434,234.907993288654),(-640726.325985575,-1063748.57857342,237.343346581407)) | 8 | propustky-zpevnění dlažbou | Barva_8 | 3.08024 | 3.08531 | zpevnění dlažbou | propustky | 465512 | I1+S1+E1+Z1+M2+F1 | lomový kámen | tl. 200 mm správáno MC25 XF4 | 128;128;128 | P50 | CZ_M2 - Plocha: 30.4381; Způsob stanovení plochy: 3D plocha TIN povrchu
založení-patka _ pás | no | 6.52136 | 1 | ((-640738.317520883,-1063771.5232687,234.507993403413),(-640735.462947717,-1063769.75336558,235.272803348579)) | 6 | založení-patka _ pás | Barva_6 | 3.08127 | 3.08426 | patka / pás | založení | 467314 | I1+S1;4+E1+Z1+M3+F1 | beton | nerelevantni | 255;0;255 | P10 | 0.724521 | řezová metoda | CZ_S4 - Beton: C25/30 XF3; Specifikace: nerelevantni; Typ betonářské vyztuže: nerelevantni; Množství betonářské výztuže na m3: 0; Množství betonářské výztuže: 0; Typ předpínací vyztuže: nerelevantni; Množství předpínací výztuže: 0; Referencované výkresy: D.1.5.2; Návrhová životnost: 25 let
propustky-lože | no | 63.1658 | 1 | ((-640738.129723468,-1063771.17009434,234.807993288654),(-640726.325985575,-1063748.57857342,237.143346581407)) | 16 | propustky-lože | Barva_16 | 3.08024 | 3.08531 | lože | propustky | 45131A | I1+S1;4+E1+Z1+M3+F1 | beton | nerelevantni | 128;0;0 | P50 | 2.71465 | řezová metoda | CZ_S4 - Beton: C20/25nXF3; Specifikace: nerelevantni; Typ betonářské vyztuže: nerelevantni; Množství betonářské výztuže na m3: 0; Množství betonářské výztuže: 0; Typ předpínací vyztuže: nerelevantni; Množství předpínací výztuže: 0; Referencované výkresy: D.1.5.2; Návrhová životnost: 25 let
propustky-podkladní vrstva | no | 63.1658 | 1 | ((-640738.129723468,-1063771.17009434,234.707993288654),(-640726.325985575,-1063748.57857342,237.043346581407)) | 2 | propustky-podkladní vrstva | Barva_2 | 3.08024 | 3.08531 | podkladní vrstva | propustky | 45157 | I1+S1+E1+Z1+M3+F1 | ŠP | nerelevantni | 255;255;0 | P50 | 2.71466 | řezová metoda
propustky-obetonování | yes | 13.047 | 2 | ((-640737.11103453,-1063769.69105935,234.757000000001),(-640734.707894182,-1063766.69221756,236.083100000001)) | 8 | propustky-obetonování | Barva_8 | 3.08202 | 3.08356 | obetonování | propustky | 45131A | I1+S1+E1+Z1+M3+F1 | beton | C20/25nXF3 | 128;128;128 | P50 | 1.5333 | řezová metoda
propustky-podkladní vrstva | no | 92.5387 | 1 | ((-640737.343886057,-1063769.78205477,234.607000000001),(-640728.036206785,-1063750.12464809,235.834000000001)) | 2 | propustky-podkladní vrstva | Barva_2 | 3.08173 | 3.08382 | podkladní vrstva | propustky | 45157 | I1+S1+E1+Z1+M3+F1 | ŠP | nerelevantni | 255;255;0 | P50 | 5.81646 | řezová metoda
propustky-zásypy a obsypy | no | 155.025 | 1 | ((-640737.523056363,-1063769.85007566,234.607000000001),(-640727.843702165,-1063750.04880328,236.934000000001)) | 40 | propustky-zásypy a obsypy | Barva_40 | 3.08132 | 3.08423 | zásypy a obsypy | propustky | 45157 | I1+S1;3+E1+Z1+M3+F1 | ŠP | nerelevantni | 255;165;0 | P50 | 32.2432 | řezová metoda | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni
propustky-propust | no | 90.5184 | 1 | ((-640736.523959479,-1063769.37300291,235.657459503737),(-640728.814444421,-1063750.4833663,236.644399852462)) | 8 | propustky-propust | Barva_8 | 3.08237 | 3.08318 | propust | propustky | 87460 | I1+S1;2+E1+Z1+M1+F1 | PP SN16 | nerelevantni | 128;128;128 | P10 | CZ_M1 - Délka: 20.3; Způsob stanovení délky: Délka 3D křivky; CZ_S2 - Reference: D.1.5.2; Typ stavebního výrobku: propustek; Stavební výrobek: potrubí; Specifikace: PP SN16 DN800; Podrobná specifikace: nerelevantni; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni
propustky-zásypy a obsypy | yes | 60.757 | 2 | ((-640736.161042353,-1063767.26008941,235.683099999996),(-640729.215410673,-1063752.63729939,236.234000000007)) | 40 | propustky-zásypy a obsypy | Barva_40 | 3.08199 | 3.08356 | zásypy a obsypy | propustky | 45157 | I1+S1;3+E1+Z1+M3+F1 | ŠP | nerelevantni | 255;165;0 | P50 | 3.95837 | řezová metoda | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni
propustky-obetonování | yes | 13.5592 | 2 | ((-640730.668558844,-1063753.20517124,234.957100000001),(-640728.269058312,-1063750.21564351,236.244499207944)) | 8 | propustky-obetonování | Barva_8 | 3.08198 | 3.08357 | obetonování | propustky | 45131A | I1+S1+E1+Z1+M3+F1 | beton | C20/25nXF3 | 128;128;128 | P50 | 1.72411 | řezová metoda
